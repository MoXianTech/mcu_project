# Keil uVision project Project.uvprojx, settings and files
target GD32E10X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103VB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL
  c include: ..\..\Firmware\CMSIS;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\Bsp;..\..\Imu;..\..\Control;..\..\Sdk;..\..\math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32e10x_it.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Peripherals
    ../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Bsp
    ../../Bsp/: 74HC4051BQ.c adc.c flash.c timer.c uart.c circular_buffer.c i2c.c oled.c can.c led.c ble_type_E104.c aid_agreement.c cJSON.c malloc.c ai_json.c ESP32_WROOM_WIFI.c at_commit_base.c ble_bt677c.c
  group math
    ../../math/: resi_math.lib resi_math_lib.h
