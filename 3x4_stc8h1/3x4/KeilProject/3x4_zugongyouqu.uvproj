# Keil uVision project 3x4_zugongyouqu.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 3x4_zugongyouqu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Firmware
  link misc: REMOVEUNUSED
  group Application
    ./: main.c math_sensor.c
  group Fimware
    ../Firmware/: STC8G_H_ADC.c STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_UART.c STC8G_H_UART_Isr.c
