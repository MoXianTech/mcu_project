# Keil uVision project cdc_acm.uvprojx, settings and files
target cdc_acm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cdc_acm +hex (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,USE_USB_FS GD32E103R_START
  c misc: --c99
  c include: ..\inc;..\CMSIS\GD\GD32E10x\Include;..\GD32E10x_standard_peripheral\Include;..\GD32E10x_usbfs_library\driver\Include;..\GD32E10x_usbfs_library\device\core\Include;..\GD32E10x_usbfs_library\device\class\cdc\Include;..\GD32E10x_usbfs_library\ustd\common;..\GD32E10x_usbfs_library\ustd\class\cdc;..\Utilities;..\CMSIS;..\GD32E10x_EVAL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../src/: app.c gd32e10x_hw.c gd32e10x_it.c
  group CMSIS
    ../CMSIS/: system_gd32e10x.c
  group GD32E10x_StdPeriph_Driver
    ../GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c
  group GD32E10x_EVAL
    ../GD32E10x_EVAL/: gd32e10x_eval.c
  group USB_Drivers
    ../GD32E10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../GD32E10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../GD32E10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Startup
    ../CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
