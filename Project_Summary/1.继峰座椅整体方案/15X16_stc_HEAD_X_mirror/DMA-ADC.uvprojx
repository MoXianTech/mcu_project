# Keil uVision project DMA-ADC.uvprojx, settings and files
target Target 1 (MCS-251)
  device: STC32G8K64 Series STC
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x117FF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: DMA-ADC +hex
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: isr.asm main.c STC32G_ADC.c STC32G_ADC_Isr.c STC32G_Delay.c STC32G_DMA.c STC32G_DMA_Isr.c STC32G_GPIO.c STC32G_NVIC.c STC32G_UART.c STC32G_UART_Isr.c adc.c led.c
