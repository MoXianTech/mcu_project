# Keil uVision project Project.uvprojx, settings and files
target GD32E10X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103CB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,USE_USB_FS GD32E103V_EVAL
  c include: ..\..\Firmware\CMSIS;..\;..\..\Utilities\LCD_Commom;..\..\Firmware\CMSIS\GD\GD32E10x\Include;..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\Bsp;..\..\Imu;..\..\Control;..\..\Sdk;..\..\GD32E10x_usbfs_library\driver\Include;..\..\GD32E10x_usbfs_library\device\class\cdc\Include;..\..\GD32E10x_usbfs_library\device\core\Include;..\..\GD32E10x_usbfs_library\ustd\common;..\..\GD32E10x_usbfs_library\ustd\class\cdc;..\Keil_project;..\Keil_project;..\..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c systick.c gd32e10x_it.c gd32e10x_hw.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Peripherals
    ../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Bsp
    ../../Bsp/: 74HC4051BQ.c adc.c uart.c scan.c 74hc595.c
    ./: circular_buffer.c
  group Lib
    ../../Lib/: Process.lib
    $TC_ROOT$/../../Users/abbott/Desktop/take/takeoff/mx_project/git_project/mcu_project/xwq/24x40/software_40x24/Lib/: math_resi.lib
