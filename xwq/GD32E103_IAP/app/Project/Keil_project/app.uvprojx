# Keil uVision project app.uvprojx, settings and files
target GD32E10X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103RB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL
  c include: ..\..\Bsp;..\..\Firmware\GD32E10x_standard_peripheral\Include;..\..\Project;..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32E10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: gd32e10x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Peripherals
    ../../Firmware/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Bsp
    ../../Bsp/: circular_buffer.c ebus.c uart.c led.c
