# Keil uVision project cdc_acm.uvprojx, settings and files
target cdc_acm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.2.1
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cdc_acm +hex (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,USE_USB_FS GD32E103R_START
  c misc: --c99
  c include: ..\inc;..\CMSIS\GD\GD32E10x\Include;..\GD32E10x_standard_peripheral\Include;..\GD32E10x_usbfs_library\driver\Include;..\GD32E10x_usbfs_library\device\core\Include;..\GD32E10x_usbfs_library\device\class\cdc\Include;..\GD32E10x_usbfs_library\ustd\common;..\GD32E10x_usbfs_library\ustd\class\cdc;..\Utilities;..\CMSIS;..\GD32E10x_EVAL
  memory RVCT4: ROM 0x8002000 size 0xe000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../src/: resi_math_lib.c
  group Doc
    ../: readme.txt
