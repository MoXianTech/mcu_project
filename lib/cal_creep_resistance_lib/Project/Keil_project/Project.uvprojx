# Keil uVision project Project.uvprojx, settings and files
target GD32470V_START (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F470,USE_USB_FS,USE_STDPERIPH_DRIVER
  c include: ..\..\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\GD32F4xx_Firmware_Library\CMSIS;..\..\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\Utilities;..\..\Project;..\..\Bsp;..\..\Lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Lib
    ../../math/: cal_creep_resistance.c
