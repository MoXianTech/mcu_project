# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CSA37F72 Chipsea
  pack: Chipsea.CSA37F7x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0xF000) IROM2(0x00100000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: project
  AfterMake: fromelf --bincombined --output .\Objects\project.bin .\Objects\project.axf
  AfterMake: .\bin\build_nfw.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Src\App;.\Src\FrameWork;.\Src\Hal
  asm include: .\Src\App;.\Src\FrameWork;.\Src\Hal
  memory RVCT4: ROM 0x0 size 0xf000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./Src/App/: interrupt.c main.c
  group FrameWork
    ./Src/FrameWork/: framework_debug.c framework_notify.c framework_pmu.c framework_reg.c framework_sample.c framework_sample_all.c framework_sample_tk.c framework_system.c
  group Hal
    ./Src/Hal/: hal_afe.c hal_common.c hal_gpio.c hal_iic.c hal_pmu.c hal_soft_iic.c hal_storage.c hal_temperature.c hal_timer.c hal_tk.c hal_uart.c hal_wdt.c
software components: CMSIS:CORE 5.4.0, Device:HAL:AFE2 1.0.0, Device:HAL:Flash 1.0.0, Device:HAL:Framework 1.0.0, Device:HAL:GPIO 1.0.0, Device:HAL:I2C 1.0.0, Device:HAL:IWDT 1.0.0, Device:HAL:PWR 1.0.0, Device:HAL:RCC 1.0.0, Device:HAL:SYSCFG 1.0.0, Device:HAL:TIM 1.0.0, Device:HAL:TIM1 1.0.0, Device:HAL:TK 1.0.0, Device:HAL:USART 1.0.0, Device:HAL:WWDT 1.0.0, Device:Startup 1.0.1
